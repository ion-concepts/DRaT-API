options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: sign_magnitude
    output_language: python
    title: Sign-Magnitude format example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: scale
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,0
    label: Sign-magnitude scale
    type: real
    value: '4.0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: 2 * samp_rate / 1000
    offset: '-1'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: drat_convert_from_signmag_0
  id: drat_convert_from_signmag
  parameters:
    mag_first: 'True'
    scale: scale
    type: float
    vlen_in: '2'
    vlen_out: '1'
  states: {}
- name: drat_convert_from_signmag_0_0
  id: drat_convert_from_signmag
  parameters:
    mag_first: 'True'
    scale: scale / 2**15
    type: short
    vlen_in: '2'
    vlen_out: '1'
  states: {}
- name: drat_convert_to_signmag_0
  id: drat_convert_to_signmag
  parameters:
    mag_first: 'True'
    scale: scale
    type: float
    vlen_in: '1'
    vlen_out: '2'
  states: {}
- name: drat_convert_to_signmag_0_0
  id: drat_convert_to_signmag
  parameters:
    mag_first: 'True'
    scale: scale / 2**15
    type: short
    vlen_in: '1'
    vlen_out: '2'
  states: {}
- name: drat_udp_sink_0
  id: drat_udp_sink
  parameters:
    async_mode: 'True'
    burst_mode: 'False'
    custom_drat_types: 'False'
    dest_addr: 127.0.0.1
    dest_port: '1234'
    drat_type: '0'
    drat_type_eob: '0'
    flow_id: '0'
    initial_time: '0.0'
    len_tag_key: ''
    maximum_latency: '100'
    packet_size: '1472'
    samp_rate: samp_rate
    self_clocked: 'True'
    status_addr: ''
    status_filter_flow: 'False'
    status_flow_id: '0'
    status_port: '1234'
    ticks_per_sample: '1'
    time_report_addr: 0.0.0.0
    time_report_filter_flow: 'False'
    time_report_flow_id: '0'
    time_report_port: '1234'
    timestamp_epoch: '0.0'
    type: complex16
  states: {}
- name: drat_udp_sink_0_0
  id: drat_udp_sink
  parameters:
    async_mode: 'True'
    burst_mode: 'False'
    custom_drat_types: 'False'
    dest_addr: 127.0.0.1
    dest_port: '1235'
    drat_type: '0'
    drat_type_eob: '0'
    flow_id: '0'
    initial_time: '0.0'
    len_tag_key: ''
    maximum_latency: '100'
    packet_size: '1472'
    samp_rate: samp_rate
    self_clocked: 'True'
    status_addr: ''
    status_filter_flow: 'False'
    status_flow_id: '0'
    status_port: '1234'
    ticks_per_sample: '1'
    time_report_addr: 0.0.0.0
    time_report_filter_flow: 'False'
    time_report_flow_id: '0'
    time_report_port: '1234'
    timestamp_epoch: '0.0'
    type: complex16
  states: {}
- name: drat_udp_source_0
  id: drat_udp_source
  parameters:
    burst_mode: 'False'
    custom_drat_types: 'False'
    drat_type: '0'
    drat_type_eob: '0'
    filter_flow: 'False'
    flow_id: '0'
    listen_addr: 0.0.0.0
    listen_port: '1234'
    recv_timeout: '1000'
    samp_rate: samp_rate
    send_ack_every: '0'
    status_addr: ''
    status_flow_id: '0'
    status_port: '1234'
    ticks_per_sample: '1'
    timestamp_epoch: '0.0'
    type: complex16
    zero_fill_lost: 'False'
  states: {}
- name: drat_udp_source_0_0
  id: drat_udp_source
  parameters:
    burst_mode: 'False'
    custom_drat_types: 'False'
    drat_type: '0'
    drat_type_eob: '0'
    filter_flow: 'False'
    flow_id: '0'
    listen_addr: 0.0.0.0
    listen_port: '1235'
    recv_timeout: '1000'
    samp_rate: samp_rate
    send_ack_every: '0'
    status_addr: ''
    status_flow_id: '0'
    status_port: '1234'
    ticks_per_sample: '1'
    timestamp_epoch: '0.0'
    type: complex16
    zero_fill_lost: 'False'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      For transmission over DRaT on a little-endian platform,
      "Magnitude First" needs to be enabled. This is because
      DRaT always sends int16_t's in MSB order, so on a
      little-endian platform it byteswaps its int16_t input.

      For other uses, such as writing to a File Sink, "Magintude
      First" needs to be disabled.
    note: About endianness
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0
    label1: Input
    name: Input
    size: '1000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0
    label1: Float conversion
    label2: Short conversion
    name: Output
    nconnections: '2'
    size: '1000'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_short_0, '0', drat_convert_to_signmag_0_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_throttle2_0, '0', blocks_float_to_short_0, '0']
- [blocks_throttle2_0, '0', drat_convert_to_signmag_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [drat_convert_from_signmag_0, '0', qtgui_time_sink_x_0_0, '0']
- [drat_convert_from_signmag_0_0, '0', blocks_short_to_float_0, '0']
- [drat_convert_to_signmag_0, '0', drat_udp_sink_0, '0']
- [drat_convert_to_signmag_0_0, '0', drat_udp_sink_0_0, '0']
- [drat_udp_source_0, '0', drat_convert_from_signmag_0, '0']
- [drat_udp_source_0_0, '0', drat_convert_from_signmag_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
